# Keil uVision project Infantry.uvprojx, settings and files
target Infantry (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Infantry
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c misc: --C99
  c include: ..\USER\Inc;..\Library\STM32F4xx_HAL_Driver\Inc;..\Library\STM32F4xx_HAL_Driver\Inc\Legacy;..\Library\CMSIS\Include;..\Library\CMSIS\Device\ST\STM32F4xx\Include;..\FreeRTOS\portable\MemMang;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\FreeRTOS\include;..\TASK\User;..\BSP\BSP_GPIO;..\BSP\BSP_TIM;..\BSP\BSP_CAN;..\BSP\BSP_USART;..\Control\Ctrl_Chassis;..\Control\Ctrl_Cloud;..\Control\Ctrl_Frict;..\Control\Ctrl_Rammer;..\Driver\Dirver_OLED;..\Driver\Driver_DBUS;..\Driver\Driver_Judge;..\Driver\Driver_PID;..\Driver\Driver_Niming;..\BSP\BSP_I2C;..\TASK\Ctrl;..\BSP\BSP_NVIC;..\TASK\Can
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Library
    ../Library/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Library/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr_ex.c
  group USER
    ../USER/Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c SystemClock.c
    ../USER/Inc/: User_typedefs.h
  group Control
    ../Control/Ctrl_Chassis/: Ctrl_Chassis.c
    ../Control/Ctrl_Cloud/: Ctrl_Cloud.c
    ../Control/Ctrl_Frict/: Ctrl_Frict.c
    ../Control/Ctrl_Rammer/: Ctrl_Rammer.c
  group Driver
    ../Driver/Driver_PID/: Driver_PID.c
    ../Driver/Driver_DBUS/: Driver_DBUS.c
    ../Driver/Driver_Judge/: Driver_Judge.c
    ../Driver/Dirver_OLED/: Dirver_OLED.c
    ../Driver/Driver_Niming/: Driver_Niming.c
  group TASK
    ../TASK/User/: Task_User.c
    ../TASK/Ctrl/: Task_Ctrl.c
    ../TASK/Can/: Task_Can.c
  group BSP
    ../BSP/BSP_CAN/: BSP_CAN.c
    ../BSP/BSP_GPIO/: BSP_GPIO.c
    ../BSP/BSP_TIM/: BSP_TIM.c
    ../BSP/BSP_USART/: BSP_USART.c
    ../BSP/BSP_I2C/: BSP_I2C.c
    ../BSP/BSP_NVIC/: BSP_NVIC.c
  group MDK
    ./: startup_stm32f427xx.s
  group Docs
    ../: README.md
